# Keil uVision project FreeRTOSforF429ZIT6.uvprojx, settings and files
target F429ZIT6 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOSforF429ZIT6
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\FreeRTOSforF429ZIT6;.\Code\inc;.\CMSIS\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Code
    ./Code/src/: main.c
  group Startup
    ./Startup/: startup_stm32f429xx.s
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
